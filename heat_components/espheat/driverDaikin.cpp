
#include <esp_log.h>
#include <cstdio>

#include "driverDaikin.h"

static const char *TAG = "DriverDaikin";


// Static
// ==========================================================================
// CRC Calculation
// ==========================================================================
const uint8_t DriverDaikin::CRC_TABLE[256] = {
    0x00, 0xd0, 0x13, 0xc3, 0x26, 0xf6, 0x35, 0xe5, 0x4c, 0x9c, 0x5f, 0x8f,
    0x6a, 0xba, 0x79, 0xa9, 0x98, 0x48, 0x8b, 0x5b, 0xbe, 0x6e, 0xad, 0x7d,
    0xd4, 0x04, 0xc7, 0x17, 0xf2, 0x22, 0xe1, 0x31, 0x83, 0x53, 0x90, 0x40,
    0xa5, 0x75, 0xb6, 0x66, 0xcf, 0x1f, 0xdc, 0x0c, 0xe9, 0x39, 0xfa, 0x2a,
    0x1b, 0xcb, 0x08, 0xd8, 0x3d, 0xed, 0x2e, 0xfe, 0x57, 0x87, 0x44, 0x94,
    0x71, 0xa1, 0x62, 0xb2, 0xb5, 0x65, 0xa6, 0x76, 0x93, 0x43, 0x80, 0x50,
    0xf9, 0x29, 0xea, 0x3a, 0xdf, 0x0f, 0xcc, 0x1c, 0x2d, 0xfd, 0x3e, 0xee,
    0x0b, 0xdb, 0x18, 0xc8, 0x61, 0xb1, 0x72, 0xa2, 0x47, 0x97, 0x54, 0x84,
    0x36, 0xe6, 0x25, 0xf5, 0x10, 0xc0, 0x03, 0xd3, 0x7a, 0xaa, 0x69, 0xb9,
    0x5c, 0x8c, 0x4f, 0x9f, 0xae, 0x7e, 0xbd, 0x6d, 0x88, 0x58, 0x9b, 0x4b,
    0xe2, 0x32, 0xf1, 0x21, 0xc4, 0x14, 0xd7, 0x07, 0xd9, 0x09, 0xca, 0x1a,
    0xff, 0x2f, 0xec, 0x3c, 0x95, 0x45, 0x86, 0x56, 0xb3, 0x63, 0xa0, 0x70,
    0x41, 0x91, 0x52, 0x82, 0x67, 0xb7, 0x74, 0xa4, 0x0d, 0xdd, 0x1e, 0xce,
    0x2b, 0xfb, 0x38, 0xe8, 0x5a, 0x8a, 0x49, 0x99, 0x7c, 0xac, 0x6f, 0xbf,
    0x16, 0xc6, 0x05, 0xd5, 0x30, 0xe0, 0x23, 0xf3, 0xc2, 0x12, 0xd1, 0x01,
    0xe4, 0x34, 0xf7, 0x27, 0x8e, 0x5e, 0x9d, 0x4d, 0xa8, 0x78, 0xbb, 0x6b,
    0x6c, 0xbc, 0x7f, 0xaf, 0x4a, 0x9a, 0x59, 0x89, 0x20, 0xf0, 0x33, 0xe3,
    0x06, 0xd6, 0x15, 0xc5, 0xf4, 0x24, 0xe7, 0x37, 0xd2, 0x02, 0xc1, 0x11,
    0xb8, 0x68, 0xab, 0x7b, 0x9e, 0x4e, 0x8d, 0x5d, 0xef, 0x3f, 0xfc, 0x2c,
    0xc9, 0x19, 0xda, 0x0a, 0xa3, 0x73, 0xb0, 0x60, 0x85, 0x55, 0x96, 0x46,
    0x77, 0xa7, 0x64, 0xb4, 0x51, 0x81, 0x42, 0x92, 0x3b, 0xeb, 0x28, 0xf8,
    0x1d, 0xcd, 0x0e, 0xde};

DriverDaikin::DriverDaikin()
{
    ESP_LOGI(TAG, "DriverDaikin::DriverDaikin() starting");
}

DriverDaikin::~DriverDaikin()
{

}

void DriverDaikin::callback(const std::vector<uint8_t>& buffer)
{
    printPacket(buffer);

    // Validate CRC
    uint8_t received_crc = buffer.back();
    uint8_t calculated_crc = computeCRC( buffer);

    if (received_crc != calculated_crc) {
        ESP_LOGE(TAG, "CRC error: received 0x%02X, calculated 0x%02X (len=%lu)",
                received_crc, calculated_crc, buffer.size());
        ESP_LOG_BUFFER_HEXDUMP(TAG, buffer.data(), buffer.size(), ESP_LOG_INFO);
        return;
    }

}

//static 
uint8_t DriverDaikin::computeCRC(const std::vector<uint8_t>& data)
{
    uint8_t crc = 0;
    for (size_t i = 0; i < data.size() - 1; i++) {
        crc = CRC_TABLE[(crc ^ data[i]) & 0xFF];
    }
    return crc;
}

//static 
void DriverDaikin::printPacket(const std::vector<uint8_t>& data)
{
    // Each byte needs 3 chars ("xx "), plus prefix (~15) and suffix
    static constexpr size_t MAX_PRINT_BYTES = 48;
    char str[16 + MAX_PRINT_BYTES * 3 + 2];
    char *p = str;

    size_t print_len = (data.size() > MAX_PRINT_BYTES) ? MAX_PRINT_BYTES : data.size();
    p += sprintf(str, "len=%02d pkt=[", data.size());
    for (size_t i = 0; i < print_len; i++) {
        p += sprintf(p, "%02x ", data[i]);
    }
    if (print_len > 0) {
        *(p - 1) = ']';
    } else {
        *p++ = ']';
    }
    *p = 0;
    ESP_LOGV(TAG, "%s", str);
}


// Static
void DriverDaikin::printDashboard()
{
    // Move cursor to top-left corner without clearing
    printf("\e[H");
    /*

    // Draw the static interface layout
    printf("-------------------------------------------------------------------------\n");
    printf("|                          AHD20 Controller Table                       |\n");
    printf("-------------------------------------------------------------------------\n");
    
    // Print dynamic data in fixed rows
    printf("|    Slave ID  0x%02X     |    Num of frames " RED "%*ld" RESET "   |    Function 0x%02X   |\n", 
                            _slaveId, 5, _nFrame, _function);
    printf("| Address requested by slave  0x%04X   |   Number of registers 0x%04X   |\n",
        _writeAdd, _nWrite);
    printf("-------------------------------------------------------------------------\n");
    printf("| Last Error: "RED"%*s"RESET"|\n", 58, _lastErr.c_str());
    
    _registerMap.lock();
    for (uint8_t i = 0; i <  _registerMap.size(); ++i) {
        if ((i >0 )&&(i % DISPLAY_N_PER_LINE == 0)) // Go to new line if i is multiple of num per line
            printf("|\n");
        auto data = _registerMap.at(i);
        printf("| 0x%04X : ", data.address);
        
        if(data.updated)
            printf(RED);
        
        printf("%*d ", 6, data.value);

        if(data.updated)
            printf(RESET);
        
    }
    _registerMap.unlock();
    */

}